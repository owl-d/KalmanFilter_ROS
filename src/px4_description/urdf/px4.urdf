Commit message: position update

File: src/px4_description/urdf/px4.urdf (robot description, URDF)
Before this commit: robot PX4_orientation, 3 links, 2 joints
Links:
- link arrow: geometry visual box size=0.25 0.25 0.2
- link box: geometry visual box size=0.9 0.5 0.25
